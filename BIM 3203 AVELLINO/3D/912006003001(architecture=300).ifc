Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_4/temp/tmp_3608_1_qpqq7/format_1/912006003001(architecture=300).ifc
Time: 2024-01-17T10:04:45
Made in: PARTsolutions

# IfcProject, 912006003001(architecture=300)
Description: AVELLINO wash bowl 3203

# IfcDiscreteAccessory, 912006003001(architecture=300)
In: BUILDING
Description: 912006003001(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 912006003001
ePset_PARTsolutions - NB: 912006003001(architecture=300); NN: 912006003001; NT: AVELLINO wash bowl 3203; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 912006003001(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 912006003001; B: 3203.png; C: AVELLINO wash bowl 3203; D: 3.7; E: KALDEWEI; F: 4055761329088; M: Furnishing Element; N: IfcSanitaryTerminalType; O: SS-35-65-70-94; P: Wash Basin Systems; Q: 23-31-13-11; R: RVT_METRICPLUMBINGFIXTURE; S: EC011550; EF002169: enamelled steel (EV000166); EF000139: Enamelled (EV002029); EF000051: round Bowl (EV000167); EF000007: alpine white (EV000202); EF000003: post top (EV003651); EF000049: 300; EF004567: 300; EF000040: 120
